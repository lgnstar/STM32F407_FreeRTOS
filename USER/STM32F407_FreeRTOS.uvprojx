# Keil uVision project STM32F407_FreeRTOS.uvprojx, settings and files
target STM32F407_FreeRTOS (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407_freertos +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\HARDWARE;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM4F;..\FreeRTOS\config;..\TaskAPP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group FreeRTOS_CONFIG
    ../FreeRTOS/config/: FreeRTOSConfig.h
  group USER
    ./: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group HARDWARE
    ../HARDWARE/: led.c
  group TaskApp
    ../TaskAPP/: led_task.c run_task.c
  group README
    ../: readme.md readme_en.md
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
